# Keil uVision project Template.uvprojx, settings and files
target Template (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Template +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F103xB
  c include: ..\Libraries\CMSIS\Device\ST\STM32F1xx\Include;..\Libraries\CMSIS\Include;..\Libraries\STM32F1xx_HAL_Driver\Inc;..\User;..\User\led;..\User\usart;..\User\dwt;..\Hardware\dht11;..\User\i2c;..\Hardware\oled;..\FreeRTOS\Inc;..\FreeRTOS\Portable\MemMang;..\FreeRTOS\Portable\RVDS\ARM_CM3;..\FreeRTOS\Scr;..\Hardware\esp8266
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group STARTUP
    ../Libraries/CMSIS/Device/ST/STM32F1xx/Source/Templates/arm/: startup_stm32f103xb.s
  group CMSIS
    ../Libraries/CMSIS/Device/ST/STM32F1xx/Source/Templates/: system_stm32f1xx.c
  group STM32F1xx_HAL_Driver
    ../Libraries/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal.c stm32f1xx_hal_cortex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_rcc.c stm32f1xx_hal_uart.c stm32f1xx_hal_usart.c stm32f1xx_hal_exti.c stm32f1xx_hal_dma.c stm32f1xx_hal_i2c.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c
  group USER
    ../User/: main.c stm32f1xx_it.c freertos.c
    ../User/led/: bsp_led.c
    ../User/usart/: bsp_usart.c
    ../User/dwt/: bsp_dwt.c
    ../User/i2c/: bsp_i2c.c
  group DOC
    ../Doc/: readme.txt.txt
  group Hardware
    ../Hardware/dht11/: app_dht11.c bsp_dht11.c
    ../Hardware/oled/: bsp_oled.c bsp_fonts.c app_oled.c
    ../Hardware/esp8266/: bsp_esp8266.c app_esp8266.c
  group FreeRTOS
    ../FreeRTOS/Scr/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../FreeRTOS/Portable/MemMang/: heap_4.c
    ../FreeRTOS/Portable/RVDS/ARM_CM3/: port.c
